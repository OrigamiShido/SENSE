# Keil uVision project SENSE.uvprojx, settings and files
target SENSE (6210000::V6.21::ARMCLANG)
  device: MSPM0L1306 Texas Instruments
  pack: TexasInstruments.MSPM0L11XX_L13XX_DFP.1.2.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_driverlib_src_LP_MSPM0L1306_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L1306__
  c include: ..\Core\inc;..\Driver;..\Driver\CMSIS\Core\Include;..\Core\src
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\mspm0l1306.sct
  group Source
    ../: SENSE.syscfg
    ./: startup_mspm0l1306_uvision.s
    ../Core/inc/: ti_msp_dl_config.h oled.h oledfont.h eeprom_emulation_type_a.h I2C_communication.h
    ../Core/src/: empty.c ti_msp_dl_config.c oled.c eeprom_emulation_type_a.c I2C_communication.c
  group Driver
    ../Driver/ti/driverlib/: dl_adc12.c dl_aes.c dl_common.c dl_crc.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
